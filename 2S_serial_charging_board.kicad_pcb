# Repository kharar/2S_serial_charging_board

File README.md:

# 2S_serial_charging_board
Balanced serial charging board for 3 pcs 2S batteries
Made for use with my Emax TinyHawk S and probably compatible with other models

## KiCad design 2S_serial_charging_board.kicad_pcb

Board: 2 copper layers, 38.0 x 19.0 mm, 10 parts (0 on the bottom side), 11 nets.

Parts:
H1, H2: MountingHole; MountingHole_3.2mm_M3
J1, J2, J3: JST-XH3; JST_XH_B3B-XH-A_1x03_P2.50mm_Vertical
J4: JST-XH7; JST_XH_B7B-XH-A_1x07_P2.50mm_Vertical
J5, J6, J7: JST-PH2; JST_PH_B2B-PH-K_1x02_P2.00mm_Vertical
J8: Wired XT60; XT60F_edge

Connections:
unnamed: J1.1, J4.1
unnamed: J1.2, J4.2
unnamed: J1.3, J2.1, J4.3
unnamed: J2.2, J4.4
unnamed: J2.3, J3.1, J4.5
unnamed: J3.2, J4.6
unnamed: J3.3, J4.7
unnamed: J5.1, J8.2
unnamed: J5.2, J6.1
unnamed: J6.2, J7.1
unnamed: J7.2, J8.1

## Commit log

2020-09-05 Revision 1 (initial commit)
2020-09-29 Fixed the XT60 silkscreen issue
2020-10-11 Fixes from 1.st prototype run
2020-10-11 Add Github web address in silkscreen
2020-10-13 add Casing stl
2020-12-01 update casing stl
2022-04-07 Convert to KiCad 6.0
2022-04-07 Fix DRC
